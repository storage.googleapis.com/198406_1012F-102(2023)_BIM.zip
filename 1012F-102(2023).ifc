Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-05-19T15:23:44
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu May 19 15:23:44 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{1CFBBAF0-F1FA-42A3-ACCA-474C29CA4035}\ifc * Database version: 5507 * Database creation date: Thu May 19 15:23:43 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu May 19 15:23:43 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu May 19 15:23:43 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 1012F-102 Washbasin faucet, 1012F-102(2022):1012F-102 Washbasin faucet:296055
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 144 mm; FaucetNominalHeight: 147 mm; FaucetNominalWidth: 50 mm; HandShowerNominalDepth: 64 mm; HandShowerNominalHeight: 286.2 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMstone; BIMObjectName: 1012F-102(2022); ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/05/2022
Type - Green Building Properties - Approval KIWA SE Type Approval: 1490; Backflow Prevention EN1717: HC; EAN Number: 6414150099915; EN Standard: EN 817, EN 1113; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110368; NRF Number: 4200286; Sales Package dimensions (LxWxH): 540 x 146 x 59; Sales Package gross weight: 1.68 kg; Sales Package package weight: 0.18178 kg; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/1012F-102; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/1012F-102/original; URL REACH: http://static.oras.com/doc/reach; VVS Number: 703893624
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1012F-102; Catalog Drawing URL: http://static.oras.com/catdrw/1012F-102; Dimension Drawing URL: http://static.oras.com/dimdrw/1012F-102; FDV Document URL: http://www.oras.com/datasheet/1012F-102/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1012F-102; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1012F-102; Item Type: Sales item; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Denmark;Poland;Russia;Estonia;Lithuania;Latvia; Mobile Product Information URL: http://mpi.oras.com/1012F-102; Model: 1012F-102 Washbasin faucet; Name_en: 1012F-102 Washbasin faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1012F-102; Product Family: Oras Safira Eco; Product Image URL: http://static.oras.com/image/1012F-102; Product URL: http://static.oras.com/1012F-102; Spare-Part Information URL: http://static.oras.com/sp/1012F-102; Technical DataSheet URL: http://www.oras.com/datasheet/1012F-102/en; Type Name: 1012F-102 Washbasin faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: 3S-installation system for safe and simple mounting; Aerator: PCA® - constant flow rate regardless of pressure variations; Connection: Flexible inlet pipes; Connection Size: G3/8; Extensions: Chain holder without chain; Flow Rate At 300kPa With Flow Controller: 0.00988811 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Noise Class: I (ISO 3822) Oras lab.; Shower Parts: Shower holder;Shower hose (1750 mm); Spout Projection: 107 mm; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1012F-102(2022); Features: Single-lever;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1012F-102(2022); Name: 1012F-102(2022) Washbasin faucet; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x144x147 mm / Hand shower: 46x64x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0712435 m2; Volume: 0.00190568 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1012F-102(2022): 1012F-102 Washbasin faucet; Family and Type: 1012F-102(2022): 1012F-102 Washbasin faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1012F-102(2022): 1012F-102 Washbasin faucet; Type Id: 1012F-102(2022): 1012F-102 Washbasin faucet; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
